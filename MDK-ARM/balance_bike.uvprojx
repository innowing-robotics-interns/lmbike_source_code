# Keil uVision project balance_bike.uvprojx, settings and files
target balance_bike (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: balance_bike +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;      ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;      ../Drivers/STM32F1xx_HAL_Driver/Inc;      ../Middlewares/Third_Party/FreeRTOS/Source/include;      ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;      ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;      ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;      ../Drivers/CMSIS/Include;      ..\Hardwares\LED;      ..\Hardwares\MPU6050;      ..\Hardwares\FILTER;      ..\Hardwares\SOFT_IIC;      ..\Hardwares\IMU;      ..\Hardwares\IMATH;      ..\Hardwares\ANO;      ..\Hardwares\FLASH;      ..\Hardwares\OLED;      ..\Hardwares\DISPLAY;      ..\Hardwares\ENCODER;      ..\Hardwares\PID;      ..\Hardwares\BLUETOOTH;      ..\Hardwares\SERVO;      ..\Hardwares\CONTROLLER;      ..\Hardwares\ULTRASONIC
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Hardwares/LED/: led.c
    ../Hardwares/MPU6050/: mpu6050.c
    ../Hardwares/FILTER/: filter.c
    ../Hardwares/SOFT_IIC/: soft_iic.c
    ../Hardwares/IMU/: imu.c
    ../Hardwares/IMATH/: imath.c
    ../Hardwares/FLASH/: flash.c
    ../Hardwares/ANO/: ano.c
    ../Hardwares/DISPLAY/: display.c
    ../Hardwares/ENCODER/: encoder.c
    ../Hardwares/PID/: pid.c
    ../Hardwares/CONTROLLER/: controller.c
    ../Hardwares/BLUETOOTH/: bluetooth.c
    ../Hardwares/SERVO/: servo.c
    ../Hardwares/ULTRASONIC/: ultrasonic.c
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 4.3.0
